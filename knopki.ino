void knopki() { // Определение функции knopki()
  //////////////////////////////////////////////////////////////////////////////////////
  ////////////////////////////// действия при нажатии кнопок////////////////////////////
  //////////////////////////////////////////////////////////////////////////////////////
  if ( rite.isClick()) {backligh=120; 
      
      timeDisplayInterval=50; // Ускоряем обновление дисплея при нажатии кнопки
      if (vflag==0){ 
        
      //  stat_disp++;
      //  if(stat_disp>1){stat_disp=1;} // Ограничение по количеству подэкранов
      }
      else if (vflag==1){ // Меню настроек 1
        fs++;
        if(fs>6){fs=6;} // Ограничение по количеству пунктов меню
      }
      else if (vflag==2){ // Меню настроек 2 (детальные настройки)
        switch (fs) {

          case 3: min_ligh++;     if(min_ligh>1000 ){min_ligh=1000;   } settingsChanged = true; break; // Настройка мин. освещенности
          case 4: anemom_max++;    if(anemom_max>300){anemom_max=300; } settingsChanged = true; break; // Настройка макс. скорости ветра
          case 5: I_max_LR+=0.1;   if(I_max_LR>10    ){I_max_LR=10;    } settingsChanged = true; break; // Настройка макс. тока LR
          case 6: I_max_UD+=0.1;   if(I_max_UD> 10   ){I_max_UD=10;    } settingsChanged = true; break; // Настройка макс. тока UD
          
        }
      }
  }

  if (enter.isClick()) // если кнопка ентер нажата
  { backligh=120; 
    timeDisplayInterval=50; // Ускоряем обновление дисплея
    
    if (vflag == 0){ // Если на главном экране, переходим в меню настроек 1
      vflag=1;
    } else if (vflag == 1){ // Если в меню настроек 1
      vflag=2; // Переходим в меню настроек 2 (детальные настройки)
      if(fs==0){ // Если не выбран пункт, возвращаемся на главный экран (этот случай не должен возникать, если fs всегда > 0)
        hand_dvig = false;
        vflag=0;
        stat_disp=1;
      }
    } else if (vflag == 2){ // Если в меню настроек 2 (детальные настройки)
      // Для всех детальных настроек (включая бывшую настройку времени)
      vflag=1; // Возвращаемся в меню настроек 1
      fs=0; // Сбрасываем выбранный пункт
    }
    // Сохраняем настройки при выходе из меню настроек
    if (settingsChanged) {
      saveSettings();
    }
  }

  if ( left.isClick()) {backligh=120; 
      timeDisplayInterval=50; // Ускоряем обновление дисплея
      if (vflag==0){ // Главный экран
        //stat_disp--;
        //if(stat_disp<0){stat_disp=0;} // Ограничение по количеству подэкранов
      }
      else if (vflag==1){ // Меню настроек 1
        fs--;
        if(fs<1){fs=1;} // Ограничение по количеству пунктов меню
      }
      else if (vflag==2){ // Меню настроек 2 (детальные настройки)
        switch (fs) {

          case 3: min_ligh-- ;   if(min_ligh<30 ){min_ligh=30;  } settingsChanged = true; break; // Настройка мин. освещенности
          case 4: anemom_max--;  if(anemom_max<2){anemom_max=2; } settingsChanged = true; break; // Настройка макс. скорости ветра
          case 5: I_max_LR-=0.1; if(I_max_LR<0.1){I_max_LR=0.1; } settingsChanged = true; break; // Настройка макс. тока LR
          case 6: I_max_UD-=0.1; if(I_max_UD<0.1){I_max_UD=0.1; } settingsChanged = true; break; // Настройка макс. тока UD
        }
      }
  }

  ///////////////////////////////////////////////кнопки ручной коррекции
  if (vflag == 2){ // Если находимся в меню детальных настроек
    switch (fs){
      case 1: // Ручное движение LR (Left/Right)
         hand_dvig = true;
         dvig_up   = false; // Выключаем движение вверх
         dvig_down = false; // Выключаем движение вниз
         dvig_right= false;  //Выключаем движение влево
         dvig_left = false; // Выключаем движение влево
        if (rite.isHold()) { // Если кнопка "вправо" удерживается
          dvig_right= true ; // Включаем движение вправо
        }
        if (left.isHold()) { // Если кнопка "влево" удерживается
          dvig_left = true ; // Включаем движение влево
        }
        break;
      case 2: // Ручное движение UD (Up/Down)
       hand_dvig = true;
         dvig_up  = false; // Выключаем движение вверх
         dvig_down   = false; // Выключаем движение вниз
         dvig_right= false;  //Выключаем движение влево
         dvig_left = false; // Выключаем движение влево
        // ОБНОВЛЕНО: Вернул кнопки к прежнему назначению, чтобы соответствовать вашему запросу:
        // Правая кнопка -> ВВЕРХ (dvig_up)
        // Левая кнопка  -> ВНИЗ (dvig_down)
        if (rite.isHold()) { // Если кнопка "вправо" удерживается (теперь для движения ВВЕРХ)
          dvig_up   = true ; // Включаем движение вверх
        }

        if (left.isHold()) { // Если кнопка "влево" удерживается (теперь для движения ВНИЗ)
          dvig_down   = true ; // Включаем движение вниз
        }

        break;
    }
  }

  ///////////////////////////////////////////конец кнопки ручной коррекции
    if (enter.isHolded()&& vflag==0) // если кнопка центр удерживать на главном экране
      {
        timeDisplayInterval=50;
        stop_error = false;
        //if (Sost!=0){Sost=0;}else{Sost=21;}
        // Здесь можно добавить логику для удержания кнопки Enter на главном экране,
        // например, для полного останова или сброса.
      }
    if (left.isHolded()&& vflag==0) // если кнопка центр удерживать на главном экране
      {
        timeDisplayInterval=50;
        autoCalibrate();
       // Здесь можно добавить логику для удержания кнопки Enter на главном экране,
        // например, для полного останова или сброса.
      }
}
